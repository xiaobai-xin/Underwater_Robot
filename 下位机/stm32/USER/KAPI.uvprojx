# Keil uVision project KAPI.uvprojx, settings and files
target KAPI (ARM-ADS)
  device: STM32F427VI STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: KAPI +hex
  BeforeMake: C:\Keil_v5\ARM\ARMCC\bin\armcc.exe
  c flags: Optim=1 OneElfS=1
  c define: STM32F427x,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\FWLIB\inc;..\HARDWARE\PWM;..\HARDWARE\BEEP;..\HARDWARE\433M;..\HARDWARE\BNO055;..\HARDWARE\DAC;..\HARDWARE\EXTI;..\HARDWARE\HP20X;..\HARDWARE\PROPELLER;.\API;..\HARDWARE\TIMER;..\HARDWARE\ADC;..\HARDWARE\BUOYANCY;..\HARDWARE\SERVO;..\HARDWARE\EXTERNAL
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c readme.txt
    ./API/: api.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/433M/: 433m.c
    ../HARDWARE/BNO055/: bno055.c
    ../HARDWARE/DAC/: dac.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/HP20X/: hp20x.c
    ../HARDWARE/PROPELLER/: propeller.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/BUOYANCY/: buoyancy.c
    ../HARDWARE/SERVO/: servo.c
    ../HARDWARE/EXTERNAL/: external.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f427x.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_dac.c stm32f4xx_exti.c stm32f4xx_dma.c stm32f4xx_adc.c stm32f4xx_iwdg.c
  group README
    ../: readme.txt
